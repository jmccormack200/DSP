# Keil uVision project DSP_LiB.uvprojx, settings and files
target LPC4088 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: DSP_LiB
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./src/: loop_dma.c
  group drivers
    ./drivers/: audio.c delay.c dma.c gpio.c i2c.c i2s.c
    C:/Keil_v5/ARM/ARMCC/include/: math.h
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.0
